# Keil uVision project project.uvprojx, settings and files
target rtthread (6130001::V6.13.1::.\ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.11.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ENDIANNESS, SKIP_SYSCLK_INIT, __FPU_PRESENT=1, STD=C99, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c include: .;..\..\..\include;applications;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\libraries\drivers\config;packages\micropython-latest;packages\micropython-latest\port;packages\micropython-latest\port\modules;packages\micropython-latest\port\modules\machine;xip;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\wlan;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\net\lwip-2.0.2\src;..\..\..\components\net\lwip-2.0.2\src\include;..\..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\..\components\net\lwip-2.0.2\src\arch\include;..\..\..\components\net\lwip-2.0.2\src\include\netif;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\libraries\MIMXRT1062\CMSIS\Include;..\libraries\MIMXRT1062\MIMXRT1062;..\libraries\MIMXRT1062\MIMXRT1062\drivers
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c usb_cdc_test_main.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c drv_rtc.c drv_spi.c drv_i2c.c drv_pwm.c drv_adc.c drv_sdio.c drv_usbd.c
    ../libraries/drivers/usb/device/: usb_device_dci.c usb_device_ehci.c
    ../libraries/drivers/usb/phy/: usb_phy.c
  group MicroPython
    packages/micropython-latest/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c emitnxtensawin.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpy_scheduler.c mpz.c nativeglue.c nlr.c nlrpowerpc.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c profile.c pystack.c qstr.c reader.c repl.c ringbuf.c runtime.c runtime_utils.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    packages/micropython-latest/lib/mp-readline/: readline.c
    packages/micropython-latest/lib/utils/: interrupt_char.c mpirq.c printf.c pyexec.c stdout_helpers.c sys_stdio_mphal.c
    packages/micropython-latest/extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modonewire.c modubinascii.c moducryptolib.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduwebsocket.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_posix.c vfs_posix_file.c vfs_reader.c virtpin.c
    packages/micropython-latest/port/: frozen_mpy.c gccollect.c mpgetcharport.c mphalport.c mpputsnport.c mpthreadport.c mpy_main.c
    packages/micropython-latest/port/modules/: modffi.c modfile.c modnetwork.c modnetwork_wlan.c modpyb.c modrtthread.c moduos.c moduos_file.c modusocket.c modutils.c modutime.c
    packages/micropython-latest/port/modules/machine/: machine_adc.c machine_hw_i2c.c machine_hw_spi.c machine_lcd.c machine_pin.c machine_pwm.c machine_rtc.c machine_timer.c machine_uart.c machine_wdt.c modmachine.c
    packages/micropython-latest/port/modules/user/: moduserfunc.c
    packages/micropython-latest/lib/netutils/: netutils.c
    packages/micropython-latest/lib/timeutils/: timeutils.c
    packages/micropython-latest/drivers/bus/: softqspi.c softspi.c
    packages/micropython-latest/port/native/: easyflash_module.c native_module.c
  group xip
    xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_msd.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
    ../../../components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: cdc_vcom.c mstorage.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group lwIP
    ../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
  group Libraries
    ../libraries/MIMXRT1062/MIMXRT1062/: system_MIMXRT1062.c
    ../libraries/MIMXRT1062/MIMXRT1062/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_gpio.c fsl_lpuart.c fsl_lpi2c.c fsl_lpspi.c fsl_gpt.c fsl_pwm.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_adc.c fsl_usdhc.c
    ../libraries/MIMXRT1062/MIMXRT1062/arm/: startup_MIMXRT1062.s
target rtthread_sdram_ac6 (6130001::V6.13.1::.\ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.11.0.0
  cpu: as above
  output: rtthread
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: as above
